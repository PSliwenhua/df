# Keil uVision project 51McuDemoCode.uvproj, settings and files
target IRC_IWR (MCS-51)
  device: R8051XC2 CAST, Inc.
  cpu: IRAM(0-0xFF) CLOCK(24000000)  MOD517DP MDU_R515
  output: IRC_WRI +hex
  c flags: Optimize=9 SizeSpeed=1
  c include: .\Code\Src;.\Code\Inc
  link misc: REMOVEUNUSED
  group Src
    ./Code/Src/: Main.c LCD.c ADC.c APP.c BUZ.c cmt_spi3.c cmt2300a.c cmt2300a_hal.c DoorContact.c INIT.c INTERRUPT.c KEY.c LVD.c radio.c RF.c Test.c Thermistor.c ThermostaticValve.c TIMER.C delay.c system_clock.c uart.c Flash.c
